Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-01-14T10:02:58
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20181011_1500(x64) - Exporter 18.4.0.0 - ARCHICAD Connection 21.0.0.6007

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Pset_DistributionPortPipe - ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 15 mm; ConnectorDiameter: 15 mm; NominalWidth: 15 mm; NominalHeight: 15 mm
Name | FlowDirection | PortNumber
 | SOURCE | 1
 | SINK | 2

# IfcEnergyConversionDevice: temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120, RSen_56_ME_FB_radiator_jaga:temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120:1601779
In: Level 1
Type - Constraints - Default Elevation: 120 mm
Type - Construction - RSen_C_offset_from_wall: 0 mm; TBQen_C_SOg_ME_01: standard; TBQen_C_SOg_ME_02: none_gen
Type - Dimensions - RSen_C_depth: 120 mm; RSen_C_diameter: 0 mm; RSen_C_height: 203.2 mm; RSen_C_length: 402 mm
Type - Energy Analysis - TBQen_M_heat_output_for_75_65_20_0: 2820.14; TBQen_M_heat_output_for_75_65_20_1: 0; TBQen_M_heat_output_for_75_65_20_2: 0; TBQen_M_heat_output_for_75_65_20_3: 0; TBQen_M_heat_output_for_75_65_20_4: 0
Type - Identity Data - Assembly Code: 56.10.60.11; Description: jaga_tempo_wall-mounted radiator; Manufacturer: Jaga; Model: Tempo; RSen_C_code_article: TEMW.02004010.101; RSen_C_code_ETIM: Convectorradiator; RSen_C_code_ETIM_URL: https://prod.etim-international.com/Class/Details?classId=EC010152&classVersion=4; RSen_C_code_gtin: -; RSen_C_code_product: -; RSen_C_content_creator: www.thorbiq.com; RSen_C_content_date_changed: 31/07/2018; RSen_C_content_date_issue: 31/07/2018; RSen_C_content_provider: JAGA N.V.; RSen_C_content_version: 1.1.0; RSen_C_description: jaga_tempo_wall-mounted radiator; RSen_C_IFC_version: 2x3; RSen_C_license: Creative Commons Attribution NoDerivs (CC-ND); RSen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; RSen_C_model: Tempo; RSen_C_revit_version: 2016; RSen_C_type: 10; RSen_C_type_comments: wall-mounted radiator; TBQ_I BaseKeynote: 56.10.60.11; Type Comments: wall-mounted radiator; Type Name: temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120; URL: www.jaga.be
Type - Materials and Finishes - RSen_C_material: RSen_x_rgb 241 236 225 T00 white 101_gen; TBQ_I Colour: RAL 9010 - white - soft touch; TBQ_I Colour chart: 101
Type - Model Properties - RSen_C_volume: 0 m3; RSen_S_weight_net: 0; TBQ_I Depth_cm: 12; TBQ_I Height_cm: 20; TBQ_I Length_cm: 40; TBQ_I Mounting accessories: -
Type - Other - Category: Mechanical Equipment; Family Name: RSen_56_ME_FB_radiator_jaga; RSen_P_c01_description: c01_Central Heating Supply; RSen_P_c01_flow_configuration: Hydronic Supply; RSen_P_c01_flow_direction: Preset; RSen_P_c01_loss_method: Not Defined; RSen_P_c01_system_classification: In; RSen_P_c01_yes_no: yes; RSen_P_c02_description: c02_Central Heating Return; RSen_P_c02_flow_configuration: Hydronic Return; RSen_P_c02_flow_direction: Calculated; RSen_P_c02_loss_method: Not Defined; RSen_P_c02_system_classification: Out; RSen_P_c02_yes_no: yes
Pset_DistributionFlowElementCommon - Reference: RSen_56_ME_FB_radiator_jaga:temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: Jaga
Pset_ProductRequirements - Category: Mechanical Equipment
Constraints - Elevation: 0 mm; Host: Reference Plane : v_rightleft
Construction - RSen_C_accessory_ME_01: none_gen; RSen_C_accessory_ME_02: none_gen; RSen_C_accessory_ME_03: none_gen; RSen_C_accessory_ME_04: none_gen; RSen_C_accessory_ME_05: none_gen; RSen_C_alignment: Center; RSen_C_alignment_index: 0; RSen_C_connection_CHr_position: Right-Bottom; RSen_C_connection_CHr_position_index: 2; RSen_C_connection_CHs_position: Right-Bottom; RSen_C_connection_CHs_position_index: 2; RSen_C_connection_possibilities: Right-Bottom; RSen_C_connection_possibilities_index: 1; RSen_C_connection_set_CHr: RSen_56_ME_FB_CHr - connection set - SH_jaga: none; RSen_C_connection_set_CHs: RSen_56_ME_FB_CHs - connection set - SH_jaga: none; RSen_C_offset_from_base_level: 120 mm; RSen_C_thermostatic_head_index: no; RSen_C_thermostatic_head_position: Not selected; RSen_C_thermostatic_head_position_index: 1; RSen_C_thermostatic_head_type: RSen_56_ME_FB_thermostatic head - SH_thorbiq: standard; TBQen_C_GOg: no; TBQen_C_SOg: yes
Dimensions - Area: 2.6484 m2; Volume: 0.193285 m3
Energy Analysis - TBQen_M_current_heat_output_for_applied_regime: 10763.9; TBQen_M_current_heat_output_for_applied_regime_index: 0; TBQen_M_current_heat_output_for_applied_regime_info: static; TBQen_M_heat_output_for_75_65_20: 2820.14; TBQen_M_max_heat_output_for_applied_regime: 1370.25; TBQen_M_temperature_heating: 20 kg/K/s3; TBQen_M_temperature_heating_return: 45 kg/K/s3; TBQen_M_temperature_heating_supply: 55 kg/K/s3
Graphics - RSen_C_clearance_zone: no; RSen_C_connection_zone: no; RSen_C_maintenance_zone: no; RSen_C_neighbour_unit: no; RSen_C_neighbour_unit_displacement_back: 0 mm; RSen_C_neighbour_unit_displacement_front: 0 mm; RSen_C_neighbour_unit_displacement_left: 0 mm; RSen_C_neighbour_unit_displacement_right: 0 mm; TBQen_C_logo: yes
Identity Data - Mark: 1519
Mechanical - RSen_P_c01_volume_flow: 0.000100615 m3/s; RSen_P_c02_volume_flow: 0.000100615 m3/s; RSen_P_nominal_diameter_return: 15 mm; RSen_P_nominal_diameter_supply: 15 mm; System Classification: Hydronic Supply,Hydronic Return
Model Properties - RSen_C_thermostatic_head: Not selected
Other - Family: RSen_56_ME_FB_radiator_jaga: temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120; Family and Type: RSen_56_ME_FB_radiator_jaga: temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120; RSen_P_c01_diameter: 15 mm; RSen_P_c01_temperature: 55 kg/K/s3; RSen_P_c02_diameter: 15 mm; RSen_P_c02_temperature: 45 kg/K/s3; Type: RSen_56_ME_FB_radiator_jaga: temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120; Type Id: RSen_56_ME_FB_radiator_jaga: temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120
Phasing - Phase Created: New Construction
Text - RSen_C_content_manual: -
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no

# IfcSpaceHeaterType, no part of this type: temw.02004010.101 - ral 9010 - white - soft touch_jaga_tempo_lxhxd 402x203,2x120
PredefinedType: CONVECTOR; Classification: 56.10.60.11 (Uniformat); Material: RSen_x_rgb 241 236 225 T00 white 101_gen
